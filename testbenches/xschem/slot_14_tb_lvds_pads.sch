v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {slot_14_wires.sym} 0 0 0 0 {name=x1}
C {devices/lab_pin.sym} -240 -350 0 0 {name=p1 sig_type=std_logic lab=vdd_3v3}
C {devices/lab_pin.sym} -240 -330 0 0 {name=p2 sig_type=std_logic lab=vdd_1v2}
C {devices/gnd.sym} -240 -310 1 0 {name=g3 lab=GND}
C {devices/gnd.sym} -240 -290 1 0 {name=g4 lab=GND}
C {devices/lab_pin.sym} -240 -270 0 0 {name=p5 sig_type=std_logic lab=nc_enable}
C {devices/lab_pin.sym} -240 -250 0 0 {name=p6 sig_type=std_logic lab=nc_clk}
C {devices/lab_pin.sym} -240 -230 0 0 {name=p7 sig_type=std_logic lab=nc_reset}
C {devices/lab_pin.sym} -240 -210 0 0 {name=p8 sig_type=std_logic lab=nc_dig_in_23}
C {devices/lab_pin.sym} -240 -190 0 0 {name=p9 sig_type=std_logic lab=nc_dig_in_22}
C {devices/lab_pin.sym} -240 -170 0 0 {name=p10 sig_type=std_logic lab=nc_dig_in_21}
C {devices/lab_pin.sym} -240 -150 0 0 {name=p11 sig_type=std_logic lab=nc_dig_in_20}
C {devices/lab_pin.sym} -240 -130 0 0 {name=p12 sig_type=std_logic lab=nc_dig_in_19}
C {devices/lab_pin.sym} -240 -110 0 0 {name=p13 sig_type=std_logic lab=nc_dig_in_18}
C {devices/lab_pin.sym} -240 -90 0 0 {name=p14 sig_type=std_logic lab=nc_dig_in_17}
C {devices/lab_pin.sym} -240 -70 0 0 {name=p15 sig_type=std_logic lab=nc_dig_in_16}
C {devices/lab_pin.sym} -240 -50 0 0 {name=p16 sig_type=std_logic lab=nc_dig_in_15}
C {devices/lab_pin.sym} -240 -30 0 0 {name=p17 sig_type=std_logic lab=nc_dig_in_14}
C {devices/lab_pin.sym} -240 -10 0 0 {name=p18 sig_type=std_logic lab=nc_dig_in_13}
C {devices/lab_pin.sym} -240 10 0 0 {name=p19 sig_type=std_logic lab=nc_dig_in_12}
C {devices/lab_pin.sym} -240 30 0 0 {name=p20 sig_type=std_logic lab=nc_dig_in_11}
C {devices/lab_pin.sym} -240 50 0 0 {name=p21 sig_type=std_logic lab=nc_dig_in_10}
C {devices/lab_pin.sym} -240 70 0 0 {name=p22 sig_type=std_logic lab=nc_dig_in_9}
C {devices/lab_pin.sym} -240 90 0 0 {name=p23 sig_type=std_logic lab=nc_dig_in_8}
C {devices/lab_pin.sym} -240 110 0 0 {name=p24 sig_type=std_logic lab=nc_dig_in_7}
C {devices/lab_pin.sym} -240 130 0 0 {name=p25 sig_type=std_logic lab=nc_dig_in_6}
C {devices/lab_pin.sym} -240 150 0 0 {name=p26 sig_type=std_logic lab=nc_dig_in_5}
C {devices/lab_pin.sym} -240 170 0 0 {name=p27 sig_type=std_logic lab=bt_en}
C {devices/lab_pin.sym} -240 190 0 0 {name=p28 sig_type=std_logic lab=mode}
C {devices/lab_pin.sym} -240 210 0 0 {name=p29 sig_type=std_logic lab=rst}
C {devices/lab_pin.sym} -240 230 0 0 {name=p30 sig_type=std_logic lab=en}
C {devices/lab_pin.sym} -240 250 0 0 {name=p31 sig_type=std_logic lab=odt_en}
C {devices/lab_pin.sym} -240 270 0 0 {name=p32 sig_type=std_logic lab=ib0}
C {devices/lab_pin.sym} -240 290 0 0 {name=p33 sig_type=std_logic lab=ib1}
C {devices/lab_pin.sym} -240 310 0 0 {name=p34 sig_type=std_logic lab=vcm_ref}
C {devices/lab_pin.sym} 240 -350 0 1 {name=p35 sig_type=std_logic lab=nc_dig_out_11}
C {devices/lab_pin.sym} 240 -330 0 1 {name=p36 sig_type=std_logic lab=nc_dig_out_10}
C {devices/lab_pin.sym} 240 -310 0 1 {name=p37 sig_type=std_logic lab=nc_dig_out_9}
C {devices/lab_pin.sym} 240 -290 0 1 {name=p38 sig_type=std_logic lab=nc_dig_out_8}
C {devices/lab_pin.sym} 240 -270 0 1 {name=p39 sig_type=std_logic lab=nc_dig_out_7}
C {devices/lab_pin.sym} 240 -250 0 1 {name=p40 sig_type=std_logic lab=nc_dig_out_6}
C {devices/lab_pin.sym} 240 -230 0 1 {name=p41 sig_type=std_logic lab=nc_dig_out_5}
C {devices/lab_pin.sym} 240 -210 0 1 {name=p42 sig_type=std_logic lab=nc_dig_out_4}
C {devices/lab_pin.sym} 240 -190 0 1 {name=p43 sig_type=std_logic lab=nc_dig_out_3}
C {devices/lab_pin.sym} 240 -170 0 1 {name=p44 sig_type=std_logic lab=nc_dig_out_2}
C {devices/lab_pin.sym} 240 -150 0 1 {name=p45 sig_type=std_logic lab=nc_dig_out_1}
C {devices/lab_pin.sym} 240 -130 0 1 {name=p46 sig_type=std_logic lab=nc_dig_out_0}
C {devices/lab_pin.sym} 240 -110 0 1 {name=p47 sig_type=std_logic lab=clk_pad}
C {devices/lab_pin.sym} 240 -90 0 1 {name=p48 sig_type=std_logic lab=chip_p}
C {devices/lab_pin.sym} 240 -70 0 1 {name=p49 sig_type=std_logic lab=chip_n}
C {devices/lab_pin.sym} 240 -50 0 1 {name=p50 sig_type=std_logic lab=refclk_core}
C {devices/lab_pin.sym} 240 -30 0 1 {name=p51 sig_type=std_logic lab=nc_s14_an_1_esd}
C {devices/lab_pin.sym} 240 -10 0 1 {name=p52 sig_type=std_logic lab=nc_s14_an_0_esd}
C {devices/lab_pin.sym} 240 10 0 1 {name=p53 sig_type=std_logic lab=nc_analog_bus0}
C {devices/lab_pin.sym} 240 30 0 1 {name=p54 sig_type=std_logic lab=nc_analog_bus1}
C {devices/lab_pin.sym} 240 50 0 1 {name=p55 sig_type=std_logic lab=nc_analog_bus2}
C {devices/lab_pin.sym} 240 70 0 1 {name=p56 sig_type=std_logic lab=nc_analog_bus3}
T {supplies, bias, control} -1650 -1050 0 0 0.4 0.4 {}
C {devices/vsource.sym} -1500 -900 0 0 {name=Vvdd_3v3 value="3.3"}
C {devices/lab_pin.sym} -1500 -930 0 0 {name=p57 sig_type=std_logic lab=vdd_3v3}
C {devices/gnd.sym} -1500 -870 0 0 {name=g58 lab=GND}
T {3.3 V} -1460 -910 0 0 0.3 0.3 {}
C {devices/vsource.sym} -1500 -740 0 0 {name=Vvdd_1v2 value="1.2"}
C {devices/lab_pin.sym} -1500 -770 0 0 {name=p59 sig_type=std_logic lab=vdd_1v2}
C {devices/gnd.sym} -1500 -710 0 0 {name=g60 lab=GND}
T {1.2 V} -1460 -750 0 0 0.3 0.3 {}
C {devices/vsource.sym} -1500 -580 0 0 {name=Viovdd value="3.3"}
C {devices/lab_pin.sym} -1500 -610 0 0 {name=p61 sig_type=std_logic lab=iovdd}
C {devices/gnd.sym} -1500 -550 0 0 {name=g62 lab=GND}
T {pad ring, 3.3 V} -1460 -590 0 0 0.3 0.3 {}
C {devices/vsource.sym} -1500 -420 0 0 {name=Vvcm value="1.2"}
C {devices/lab_pin.sym} -1500 -450 0 0 {name=p63 sig_type=std_logic lab=vcm_ref}
C {devices/gnd.sym} -1500 -390 0 0 {name=g64 lab=GND}
T {vbias = Vref, 1.2 V} -1460 -430 0 0 0.3 0.3 {}
C {isource.sym} -1500 -260 0 0 {name=Iib0 value="-1.935u"}
C {devices/lab_pin.sym} -1500 -290 0 0 {name=p65 sig_type=std_logic lab=ib0}
C {devices/gnd.sym} -1500 -230 0 0 {name=g66 lab=GND}
T {ibias0, IDAC code 6 = 1.935uA} -1460 -270 0 0 0.3 0.3 {}
C {isource.sym} -1500 -100 0 0 {name=Iib1 value="PWL(0 -1.935u 400n -1.935u 400.1n -2.903u)"}
C {devices/lab_pin.sym} -1500 -130 0 0 {name=p67 sig_type=std_logic lab=ib1}
C {devices/gnd.sym} -1500 -70 0 0 {name=g68 lab=GND}
T {ibias1, code 6; code 9 = 2.903uA from 400 ns} -1460 -110 0 0 0.3 0.3 {}
C {devices/vsource.sym} -1500 60 0 0 {name=Vodt value="PWL(0 0 300n 0 300.1n 1.2)"}
C {devices/lab_pin.sym} -1500 30 0 0 {name=p69 sig_type=std_logic lab=odt_en_drv}
C {devices/gnd.sym} -1500 90 0 0 {name=g70 lab=GND}
C {res.sym} -1080 60 0 0 {name=Rodt_en value="100"}
C {devices/lab_pin.sym} -1080 30 0 0 {name=p71 sig_type=std_logic lab=odt_en_drv}
C {devices/lab_pin.sym} -1080 90 0 0 {name=p72 sig_type=std_logic lab=odt_en}
T {dig_in[0] ODT: off, on from 300 ns} -1460 50 0 0 0.3 0.3 {}
C {devices/vsource.sym} -1500 220 0 0 {name=Ven value="PWL(0 0 3n 0 3.1n 1.2)"}
C {devices/lab_pin.sym} -1500 190 0 0 {name=p73 sig_type=std_logic lab=en_drv}
C {devices/gnd.sym} -1500 250 0 0 {name=g74 lab=GND}
C {res.sym} -1080 220 0 0 {name=Ren value="100"}
C {devices/lab_pin.sym} -1080 190 0 0 {name=p75 sig_type=std_logic lab=en_drv}
C {devices/lab_pin.sym} -1080 250 0 0 {name=p76 sig_type=std_logic lab=en}
T {dig_in[1] en} -1460 210 0 0 0.3 0.3 {}
C {devices/vsource.sym} -1500 380 0 0 {name=Vrst value="PWL(0 1.2 2n 1.2 2.1n 0 400n 0 400.1n 1.2 402n 1.2 402.1n 0)"}
C {devices/lab_pin.sym} -1500 350 0 0 {name=p77 sig_type=std_logic lab=rst_drv}
C {devices/gnd.sym} -1500 410 0 0 {name=g78 lab=GND}
C {res.sym} -1080 380 0 0 {name=Rrst value="100"}
C {devices/lab_pin.sym} -1080 350 0 0 {name=p79 sig_type=std_logic lab=rst_drv}
C {devices/lab_pin.sym} -1080 410 0 0 {name=p80 sig_type=std_logic lab=rst}
T {dig_in[2] reset until 2 ns, again at 400 ns} -1460 370 0 0 0.3 0.3 {}
C {devices/vsource.sym} -1500 540 0 0 {name=Vmode value="1.2"}
C {devices/lab_pin.sym} -1500 510 0 0 {name=p81 sig_type=std_logic lab=mode_drv}
C {devices/gnd.sym} -1500 570 0 0 {name=g82 lab=GND}
C {res.sym} -1080 540 0 0 {name=Rmode value="100"}
C {devices/lab_pin.sym} -1080 510 0 0 {name=p83 sig_type=std_logic lab=mode_drv}
C {devices/lab_pin.sym} -1080 570 0 0 {name=p84 sig_type=std_logic lab=mode}
T {dig_in[3] mode = PRBS-7} -1460 530 0 0 0.3 0.3 {}
C {devices/vsource.sym} -1500 700 0 0 {name=Vbt value="PWL(0 0 400n 0 400.1n 1.2)"}
C {devices/lab_pin.sym} -1500 670 0 0 {name=p85 sig_type=std_logic lab=bt_en_drv}
C {devices/gnd.sym} -1500 730 0 0 {name=g86 lab=GND}
C {res.sym} -1080 700 0 0 {name=Rbt_en value="100"}
C {devices/lab_pin.sym} -1080 670 0 0 {name=p87 sig_type=std_logic lab=bt_en_drv}
C {devices/lab_pin.sym} -1080 730 0 0 {name=p88 sig_type=std_logic lab=bt_en}
T {dig_in[4] back-termination: off, on from 400 ns} -1460 690 0 0 0.3 0.3 {}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} -1000 900 0 0 {name=xpad2}
C {devices/gnd.sym} -992.5 560 0 0 {name=g89 lab=GND}
C {devices/lab_pin.sym} -982.5 570 0 0 {name=p90 sig_type=std_logic lab=vdd_1v2}
C {devices/gnd.sym} -972.5 580 0 0 {name=g91 lab=GND}
C {devices/lab_pin.sym} -960 590 0 0 {name=p92 sig_type=std_logic lab=iovdd}
C {devices/lab_pin.sym} -900 550 0 0 {name=p93 sig_type=std_logic lab=clk_pad}
C {devices/lab_pin.sym} -800 550 0 0 {name=p94 sig_type=std_logic lab=refclk_core}
C {devices/lab_pin.sym} -890 800 0 0 {name=p95 sig_type=std_logic lab=clk_pad}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 900 -300 0 0 {name=xpad1}
C {devices/gnd.sym} 907.5 -640 0 0 {name=g96 lab=GND}
C {devices/lab_pin.sym} 917.5 -630 0 0 {name=p97 sig_type=std_logic lab=vdd_1v2}
C {devices/gnd.sym} 927.5 -620 0 0 {name=g98 lab=GND}
C {devices/lab_pin.sym} 940 -610 0 0 {name=p99 sig_type=std_logic lab=iovdd}
C {devices/lab_pin.sym} 1000 -650 0 0 {name=p100 sig_type=std_logic lab=chip_p}
C {devices/lab_pin.sym} 1100 -650 0 0 {name=p101 sig_type=std_logic lab=nc_pad1_res}
C {devices/lab_pin.sym} 1010 -400 0 0 {name=p102 sig_type=std_logic lab=chip_p}
C {sg13cmos5l_io/sg13cmos5l_IOPadAnalog.sym} 900 300 0 0 {name=xpad0}
C {devices/gnd.sym} 907.5 -40 0 0 {name=g103 lab=GND}
C {devices/lab_pin.sym} 917.5 -30 0 0 {name=p104 sig_type=std_logic lab=vdd_1v2}
C {devices/gnd.sym} 927.5 -20 0 0 {name=g105 lab=GND}
C {devices/lab_pin.sym} 940 -10 0 0 {name=p106 sig_type=std_logic lab=iovdd}
C {devices/lab_pin.sym} 1000 -50 0 0 {name=p107 sig_type=std_logic lab=chip_n}
C {devices/lab_pin.sym} 1100 -50 0 0 {name=p108 sig_type=std_logic lab=nc_pad0_res}
C {devices/lab_pin.sym} 1010 200 0 0 {name=p109 sig_type=std_logic lab=chip_n}
T {pad 2: ref_clk in through padres (secondary protection), termination on the pad itself} -1000 960 0 0 0.3 0.3 {}
T {pad 1: d_p, the pad direct} 900 -240 0 0 0.3 0.3 {}
T {pad 0: d_n, the pad direct} 900 360 0 0 0.3 0.3 {}
T {ref_clk: 50 ohm generator, 50 ohm line, package, bond wire} -2450 500 0 0 0.35 0.35 {}
C {devices/vsource.sym} -2300 800 0 0 {name=Vclk_a value="PULSE(0 1.2 0 100p 100p 0.9n 2n)"}
C {devices/lab_pin.sym} -2300 770 0 0 {name=p110 sig_type=std_logic lab=clk_mid}
C {devices/gnd.sym} -2300 830 0 0 {name=g111 lab=GND}
C {devices/vsource.sym} -2300 640 0 0 {name=Vclk_b value="PULSE(0 1.2 400n 100p 100p 0.9n 2n)"}
C {devices/lab_pin.sym} -2300 610 0 0 {name=p112 sig_type=std_logic lab=clk_src}
C {devices/lab_pin.sym} -2300 670 0 0 {name=p113 sig_type=std_logic lab=clk_mid}
C {res.sym} -2140 700 0 0 {name=Rclk value="50"}
C {devices/lab_pin.sym} -2140 670 0 0 {name=p114 sig_type=std_logic lab=clk_src}
C {devices/lab_pin.sym} -2140 730 0 0 {name=p115 sig_type=std_logic lab=clk_line}
C {capa.sym} -1980 700 0 0 {name=Cpkg_clk value="0.5p"}
C {devices/lab_pin.sym} -1980 670 0 0 {name=p116 sig_type=std_logic lab=clk_pkg}
C {devices/gnd.sym} -1980 730 0 0 {name=g117 lab=GND}
C {ind.sym} -1820 700 0 0 {name=Lclk value="2n"}
C {devices/lab_pin.sym} -1820 670 0 0 {name=p118 sig_type=std_logic lab=clk_pkg}
C {devices/lab_pin.sym} -1820 730 0 0 {name=p119 sig_type=std_logic lab=clk_bw}
C {devices/vsource.sym} -1660 700 0 0 {name=Vpad2 value="0"}
C {devices/lab_pin.sym} -1660 670 0 0 {name=p120 sig_type=std_logic lab=clk_bw}
C {devices/lab_pin.sym} -1660 730 0 0 {name=p121 sig_type=std_logic lab=clk_pad}
T {Vclk_b joins at 400 ns: EMF 1.2 V before, 2.4 V after.  Vpad2 is the ammeter:
the current into pad 2, i.e. into xodt (s14_an[2]) and the pad cell} -2450 560 0 0 0.3 0.3 {}
T {d_p / d_n: bond wire, package, 50 ohm line, receiver} 1400 -760 0 0 0.35 0.35 {}
C {ind.sym} 1500 -600 0 0 {name=Lbp value="2n"}
C {devices/lab_pin.sym} 1500 -630 0 0 {name=p122 sig_type=std_logic lab=chip_p}
C {devices/lab_pin.sym} 1500 -570 0 0 {name=p123 sig_type=std_logic lab=pkg_p}
C {capa.sym} 1660 -600 0 0 {name=Cpkg_p value="0.5p"}
C {devices/lab_pin.sym} 1660 -630 0 0 {name=p124 sig_type=std_logic lab=pkg_p}
C {devices/gnd.sym} 1660 -570 0 0 {name=g125 lab=GND}
C {capa.sym} 1980 -600 0 0 {name=Crx_p value="1p"}
C {devices/lab_pin.sym} 1980 -630 0 0 {name=p126 sig_type=std_logic lab=rx_p}
C {devices/gnd.sym} 1980 -570 0 0 {name=g127 lab=GND}
C {ind.sym} 1500 -200 0 0 {name=Lbn value="2n"}
C {devices/lab_pin.sym} 1500 -230 0 0 {name=p128 sig_type=std_logic lab=chip_n}
C {devices/lab_pin.sym} 1500 -170 0 0 {name=p129 sig_type=std_logic lab=pkg_n}
C {capa.sym} 1660 -200 0 0 {name=Cpkg_n value="0.5p"}
C {devices/lab_pin.sym} 1660 -230 0 0 {name=p130 sig_type=std_logic lab=pkg_n}
C {devices/gnd.sym} 1660 -170 0 0 {name=g131 lab=GND}
C {capa.sym} 1980 -200 0 0 {name=Crx_n value="1p"}
C {devices/lab_pin.sym} 1980 -230 0 0 {name=p132 sig_type=std_logic lab=rx_n}
C {devices/gnd.sym} 1980 -170 0 0 {name=g133 lab=GND}
C {res.sym} 2140 -500 0 0 {name=Rt_p value="49.9"}
C {devices/lab_pin.sym} 2140 -530 0 0 {name=p134 sig_type=std_logic lab=rx_p}
C {devices/lab_pin.sym} 2140 -470 0 0 {name=p135 sig_type=std_logic lab=vos}
C {res.sym} 2140 -300 0 0 {name=Rt_n value="49.9"}
C {devices/lab_pin.sym} 2140 -330 0 0 {name=p136 sig_type=std_logic lab=vos}
C {devices/lab_pin.sym} 2140 -270 0 0 {name=p137 sig_type=std_logic lab=rx_n}
T {100 ohm at the receiver, mid-point = Vos} 2200 -420 0 0 0.3 0.3 {}
T {LVDS link with the IHP pads - slot_14 with its three sg13cmos5l_IOPadAnalog,
bond wire 2nH, package 0.5pF, a 50 ohm line of 200ps, the receiver 1pF + 100 ohm.

One run, three phases - the same as slot_14_tb_lvds:
  A    0 - 300 ns   ODT off, EMF 1.2 V   pad 1.2 V (the open end doubles 0.6 V)
  B  300 - 400 ns   ODT on,  EMF 1.2 V   pad halved to 0.6 V: 50 ohm into 50 ohm
  C  400 - 700 ns   ODT on,  EMF 2.4 V   pad 1.2 V, 24 mA while high; reset at 400 ns;
                                        the output back-termination on (dig_in[4]), ibias1 3 uA
The outputs are never terminated on chip.  The log prints each phase: the ODT
switch, the clock at pad 2 and behind the protection, the pad current, Vod / Vos
at the receiver and at the pads, the supplies; the rise time in A and C.

The slot: the top-level wiring as laid out (with its capacitance), the blocks from their schematics
(slot_14_wires.spice, from scripts/sim/extract_top.sh - run make extract-top after a layout change).
The pad cells are the PDK's spice model.} -1700 -1700 0 0 0.45 0.45 {}
C {devices/code_shown.sym} -1700 -2600 0 0 {name=NGSPICE
only_toplevel=true
value="
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.include ../../../models/diodes_tt0.lib
.include sg13g2_esd.lib
.include cap_cmomf.lib
.include /foss/pdks/ihp-sg13cmos5l/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice
.include /foss/pdks/ihp-sg13cmos5l/libs.ref/sg13cmos5l_io/spice/sg13cmos5l_io.spi
* the slot: the top-level wiring as laid out (with its capacitance), the blocks from their schematics
.include ../../../netlist/pex/slot_14_wires.spice
* the substrate terminal of the pads' poly resistors
.global sub!
Vsub sub! 0 0
* the board: one uncoupled 50 ohm line per leg
Tclk clk_line 0 clk_pkg 0 Z0=50 TD=200p
Tp pkg_p 0 rx_p 0 Z0=50 TD=200p
Tn pkg_n 0 rx_n 0 Z0=50 TD=200p
.temp 27
* no savecurrents: with the PEX netlist it writes thousands of device currents
.options klu method=trap reltol=1e-3 abstol=1e-12 gmin=1e-12
.ic v(x1.xlvds.xdrv.cmfb)=1.54
.control
save rx_p rx_n vos chip_p chip_n refclk_core clk_pad odt_en i(Vpad2) x1.xodt.enh x1.xodt.x
+ x1.core_p x1.core_n i(Vvdd_3v3) i(Vvdd_1v2) i(Viovdd)
tran 5p 700n 0 5p
write @schname\\\\.raw

let vd = v(rx_p)-v(rx_n)
let vdpad = v(chip_p)-v(chip_n)
meas tran enh_a AVG v(x1.xodt.enh) from=150n to=295n
meas tran x_max_a MAX v(x1.xodt.x) from=150n to=295n
meas tran pad_max_a MAX v(clk_pad) from=150n to=295n
meas tran pad_min_a MIN v(clk_pad) from=150n to=295n
meas tran ck_max_a MAX v(refclk_core) from=150n to=295n
meas tran ck_min_a MIN v(refclk_core) from=150n to=295n
meas tran ipad_max_a MAX i(Vpad2) from=150n to=295n
meas tran ipad_avg_a AVG i(Vpad2) from=150n to=295n
meas tran core_pp_a PP v(x1.core_p) from=150n to=295n
meas tran vod_max_a MAX vd from=150n to=295n
meas tran vod_min_a MIN vd from=150n to=295n
meas tran vodpad_max_a MAX vdpad from=150n to=295n
meas tran vodpad_min_a MIN vdpad from=150n to=295n
meas tran vos_avg_a AVG v(vos) from=150n to=295n
meas tran vos_pp_a PP v(vos) from=150n to=295n
meas tran i_3v3_a AVG i(Vvdd_3v3) from=150n to=295n
meas tran i_1v2_a AVG i(Vvdd_1v2) from=150n to=295n
meas tran enh_b AVG v(x1.xodt.enh) from=320n to=395n
meas tran x_max_b MAX v(x1.xodt.x) from=320n to=395n
meas tran pad_max_b MAX v(clk_pad) from=320n to=395n
meas tran pad_min_b MIN v(clk_pad) from=320n to=395n
meas tran ck_max_b MAX v(refclk_core) from=320n to=395n
meas tran ck_min_b MIN v(refclk_core) from=320n to=395n
meas tran ipad_max_b MAX i(Vpad2) from=320n to=395n
meas tran ipad_avg_b AVG i(Vpad2) from=320n to=395n
meas tran core_pp_b PP v(x1.core_p) from=320n to=395n
meas tran vod_max_b MAX vd from=320n to=395n
meas tran vod_min_b MIN vd from=320n to=395n
meas tran vodpad_max_b MAX vdpad from=320n to=395n
meas tran vodpad_min_b MIN vdpad from=320n to=395n
meas tran vos_avg_b AVG v(vos) from=320n to=395n
meas tran vos_pp_b PP v(vos) from=320n to=395n
meas tran i_3v3_b AVG i(Vvdd_3v3) from=320n to=395n
meas tran i_1v2_b AVG i(Vvdd_1v2) from=320n to=395n
meas tran enh_c AVG v(x1.xodt.enh) from=500n to=695n
meas tran x_max_c MAX v(x1.xodt.x) from=500n to=695n
meas tran pad_max_c MAX v(clk_pad) from=500n to=695n
meas tran pad_min_c MIN v(clk_pad) from=500n to=695n
meas tran ck_max_c MAX v(refclk_core) from=500n to=695n
meas tran ck_min_c MIN v(refclk_core) from=500n to=695n
meas tran ipad_max_c MAX i(Vpad2) from=500n to=695n
meas tran ipad_avg_c AVG i(Vpad2) from=500n to=695n
meas tran core_pp_c PP v(x1.core_p) from=500n to=695n
meas tran vod_max_c MAX vd from=500n to=695n
meas tran vod_min_c MIN vd from=500n to=695n
meas tran vodpad_max_c MAX vdpad from=500n to=695n
meas tran vodpad_min_c MIN vdpad from=500n to=695n
meas tran vos_avg_c AVG v(vos) from=500n to=695n
meas tran vos_pp_c PP v(vos) from=500n to=695n
meas tran i_3v3_c AVG i(Vvdd_3v3) from=500n to=695n
meas tran i_1v2_c AVG i(Vvdd_1v2) from=500n to=695n
let th20_a = vod_min_a + 0.2*(vod_max_a - vod_min_a)
let th80_a = vod_min_a + 0.8*(vod_max_a - vod_min_a)
meas tran t20_a WHEN vd=$&th20_a RISE=5 FROM=150n
meas tran t80_a WHEN vd=$&th80_a RISE=5 FROM=150n
let trise_a = t80_a - t20_a
let th20_c = vod_min_c + 0.2*(vod_max_c - vod_min_c)
let th80_c = vod_min_c + 0.8*(vod_max_c - vod_min_c)
meas tran t20_c WHEN vd=$&th20_c RISE=5 FROM=500n
meas tran t80_c WHEN vd=$&th80_c RISE=5 FROM=500n
let trise_c = t80_c - t20_c
echo === phase A - ODT off, EMF 1.2 V: pad 1.2 V, no pad current (150-295 ns)
print enh_a x_max_a pad_max_a pad_min_a ck_max_a ck_min_a ipad_max_a ipad_avg_a
print core_pp_a vod_max_a vod_min_a vodpad_max_a vodpad_min_a vos_avg_a vos_pp_a
print i_3v3_a i_1v2_a
echo === phase B - ODT on, EMF 1.2 V: pad halved to 0.6 V if the ODT is 50 ohm (320-395 ns)
print enh_b x_max_b pad_max_b pad_min_b ck_max_b ck_min_b ipad_max_b ipad_avg_b
print core_pp_b vod_max_b vod_min_b vodpad_max_b vodpad_min_b vos_avg_b vos_pp_b
print i_3v3_b i_1v2_b
echo === phase C - ODT on, EMF 2.4 V: pad 1.2 V, 24 mA while high; back-termination on, ibias1 3 uA (500-695 ns)
print enh_c x_max_c pad_max_c pad_min_c ck_max_c ck_min_c ipad_max_c ipad_avg_c
print core_pp_c vod_max_c vod_min_c vodpad_max_c vodpad_min_c vos_avg_c vos_pp_c
print i_3v3_c i_1v2_c
print trise_a trise_c
let r_odt = 50 * pad_max_b / (1.2 - pad_max_b)
echo === ODT resistance from phase B, 50 * Vpad / (1.2 V - Vpad):
print r_odt

set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/@schname\\\\.txt
+ vd vdpad v(vos) v(refclk_core) v(clk_pad) i(Vpad2) v(odt_en)
.endc
"}
C {launcher.sym} 2700 -2150 0 0 {name=h_sim
descr="Simulate"
tclcommand="
set_sim_defaults
file mkdir $netlist_dir
write_data [save_params] $netlist_dir/[file rootname [file tail [xschem get current_name]]].save
xschem netlist
set _cwd [pwd]
cd $netlist_dir
simulate
cd $_cwd
"}
C {launcher.sym} 2700 -2110 0 0 {name=h_waves
descr="Load waves"
tclcommand="xschem raw_read $netlist_dir/slot_14_tb_lvds_pads.raw tran"
}
C {launcher.sym} 2700 -2070 0 0 {name=h_check
descr="Check PRBS + timing"
tclcommand="exec python3 [file dirname [xschem get current_dirname]]/../../scripts/check_timing.py &"
}
B 2 2700 -1950 4500 -1550 {flags=graph
y1=-0.2
y2=3.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=7e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
node="odt_en
x1.xodt.enh"
color="8 10"
dataset=-1
unitx=1
logx=0
logy=0
autoload=0
hilight_wave=-1}
B 2 2700 -1450 4500 -1050 {flags=graph
y1=-0.2
y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=7e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
node="clk_pad
x1.xodt.x
refclk_core"
color="4 12 7"
dataset=-1
unitx=1
logx=0
logy=0
autoload=0
hilight_wave=-1}
B 2 2700 -950 4500 -550 {flags=graph
y1=-0.01
y2=0.03
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=7e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
node="i(vpad2)"
color="4"
dataset=-1
unitx=1
logx=0
logy=0
autoload=0
hilight_wave=-1}
B 2 2700 -450 4500 -50 {flags=graph
y1=0.9
y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=7e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
node="rx_p
rx_n
vos"
color="4 5 8"
dataset=-1
unitx=1
logx=0
logy=0
autoload=0
hilight_wave=-1}
B 2 2700 50 4500 450 {flags=graph,unlocked
y1=-0.2
y2=3.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.94e-07
x2=3.08e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
node="odt_en
x1.xodt.enh
clk_pad
x1.xodt.x"
color="8 10 4 12"
dataset=-1
unitx=1
logx=0
logy=0
autoload=0
hilight_wave=-1}
B 2 2700 550 4500 950 {flags=graph,unlocked
y1=-0.01
y2=0.03
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.94e-07
x2=3.08e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
node="i(vpad2)"
color="4"
dataset=-1
unitx=1
logx=0
logy=0
autoload=0
hilight_wave=-1}
B 2 2700 1050 4500 1450 {flags=graph,unlocked
y1=-0.2
y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=3.96e-07
x2=4.08e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
node="clk_pad
refclk_core"
color="4 7"
dataset=-1
unitx=1
logx=0
logy=0
autoload=0
hilight_wave=-1}
B 2 2700 1550 4500 1950 {flags=graph,unlocked
y1=-0.5
y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.5e-07
x2=6.6e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
node="rx_p
rx_n
\\"vd;rx_p rx_n -\\""
color="4 5 7"
dataset=-1
unitx=1
logx=0
logy=0
autoload=0
hilight_wave=-1}
B 2 2700 2050 4500 2450 {flags=graph,unlocked
y1=-0.5
y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.5e-07
x2=6.6e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
legendmag=1.0
node="chip_p
chip_n
\\"vdpad;chip_p chip_n -\\""
color="4 5 7"
dataset=-1
unitx=1
logx=0
logy=0
autoload=0
hilight_wave=-1}
