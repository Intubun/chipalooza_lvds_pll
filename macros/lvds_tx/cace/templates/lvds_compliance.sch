** sch_path: macros/lvds_tx/cace/templates/lvds_compliance.sch
**.subckt lvds_compliance
VA Va GND CACE{vdd}
.save i(va)
Vrf Vref GND CACE{vref}
Ipd Iref_pd GND -CACE{iref}
Idrv Iref_drv GND -CACE{iref}
VDp D_p GND PULSE(0 CACE{vddc} 0 CACE{tedge} CACE{tedge} 'CACE{period}/2-CACE{tedge}' CACE{period})
VDn D_n GND PULSE(0 CACE{vddc} 'CACE{period}/2' CACE{tedge} CACE{tedge} 'CACE{period}/2-CACE{tedge}'
+ CACE{period})
x1 D_p D_n Iref_pd Iref_drv Vref Va Out_p Out_n GND lvds_tx
Rp Out_p Vos 49.9 m=1
Rn Vos Out_n 49.9 m=1
**** begin user architecture code


* Corner and temperature are conditions, so one template covers the whole grid.
.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_typ
.lib cornerDIO.lib dio_tt
.include cap_cmomf.lib

* The DUT netlist: schematic, extracted layout or R-C extracted, whichever
* CACE was asked for. This one line is what makes the three columns possible.
.include CACE{DUT_path}

.temp CACE{temperature}
.option warn=1

* The common-mode loop starts far from its operating point, so the bench gives
* it a hint and then measures only well after it has settled. Measuring across
* the cold start is how a driver that is not compliant comes out looking
* compliant.
.ic v(x1.xdrv.cmfb)=CACE{cmfb_ic}




.control

    * The analysis window and the measurement window are conditions in their
    * own right rather than expressions over the bit period. ngspice's control
    * language takes plain numbers here - a quoted expression is accepted in a
    * netlist line but silently skips the analysis in a .control block, which
    * leaves every meas reporting it is limited to tran, dc, sp or ac.
    * savecurrent on the supply emits a .save line into the netlist, and a
    * single .save makes ngspice keep only what is listed - every node
    * voltage is dropped. So name everything this bench measures.
    save v(Out_p) v(Out_n) v(Vos) i(VA)

    tran CACE{tstep} CACE{tstop}

    let vod = v(Out_p)-v(Out_n)

    meas tran vod_max MAX vod    from=CACE{tmeas} to=CACE{tstop}
    meas tran vod_min MIN vod    from=CACE{tmeas} to=CACE{tstop}
    meas tran vos_max MAX v(Vos) from=CACE{tmeas} to=CACE{tstop}
    meas tran vos_min MIN v(Vos) from=CACE{tmeas} to=CACE{tstop}
    meas tran vos_avg AVG v(Vos) from=CACE{tmeas} to=CACE{tstop}
    meas tran i_va    AVG i(VA)  from=CACE{tmeas} to=CACE{tstop}

    * Clause 4.1.1 is written on the magnitude, and an unbalanced driver has
    * two different magnitudes. Report the worse one, not the average.
    let vod_mag  = min(vod_max, -vod_min)
    let vos_pp   = vos_max - vos_min
    let i_supply = -i_va

    echo $&vod_mag $&vos_avg $&vos_pp $&i_supply > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends

* expanding   symbol:  lvds_tx.sym # of pins=9
** sym_path: macros/lvds_tx/schematic/xschem/lvds_tx.sym
** sch_path: macros/lvds_tx/schematic/xschem/lvds_tx.sch
.subckt lvds_tx D_p D_n Iref_pd Iref_drv Vref Va Out_p Out_n Vss
*.ipin D_p
*.ipin D_n
*.ipin Iref_pd
*.ipin Iref_drv
*.ipin Vref
*.iopin Va
*.iopin Vss
*.opin Out_p
*.opin Out_n
Xpd D_p D_n Iref_pd In_p In_n Va Vss predriver
Xdrv Va Out_p In_p In_n Iref_drv Vref Out_n Vss Driver
.ends


* expanding   symbol:  predriver.sym # of pins=7
** sym_path: macros/lvds_tx/schematic/xschem/predriver.sym
** sch_path: macros/lvds_tx/schematic/xschem/predriver.sch
.subckt predriver D_p D_n Iref In_p In_n Va Vss
*.iopin Va
*.iopin Vss
*.ipin Iref
*.ipin D_p
*.ipin D_n
*.opin In_p
*.opin In_n
Xkpm D_p D_n Iref net1 Va Vss predriver_comp
XMref Iref Iref Vss Vss sg13_hv_nmos w=2u l=2u ng=1 m=1 mm_ok=1
Xknm D_n D_p Iref net2 Va Vss predriver_comp
Xstm net1 net2 In_p In_n Va Vss predriver_stage
.ends


* expanding   symbol:  Driver.sym # of pins=8
** sym_path: macros/lvds_tx/schematic/xschem/Driver.sym
** sch_path: macros/lvds_tx/schematic/xschem/Driver.sch
.subckt Driver Va Out_p In_p In_n Iref Vref Out_n Vss
*.iopin Va
*.iopin Vss
*.opin Out_p
*.opin Out_n
*.ipin In_p
*.ipin In_n
*.ipin Iref
*.ipin Vref
XCtn1 Va tail_n Va Va sg13_hv_pmos w=11.8u l=5.25u ng=2 m=1 mm_ok=1
XCtn2 Va tail_n Va Va sg13_hv_pmos w=5.7u l=5.8u ng=2 m=1 mm_ok=1
XM2 tail_p cmfb Va Va sg13_hv_pmos w=97.2u l=0.5u ng=20 m=1 mm_ok=1
XM5 Out_p In_p tail_p Va sg13_hv_pmos w=80u l=0.4u ng=16 m=1 mm_ok=1
XM4 Out_n In_n tail_p Va sg13_hv_pmos w=80u l=0.4u ng=16 m=1 mm_ok=1
XM1 Out_p In_p tail_n Vss sg13_hv_nmos w=30u l=0.45u ng=15 m=1 mm_ok=1
XM3 Out_n In_n tail_n Vss sg13_hv_nmos w=30u l=0.45u ng=15 m=1 mm_ok=1
XM6 tail_n Iref Vss Vss sg13_hv_nmos w=49.6u l=0.5u ng=31 m=2 mm_ok=1
XM9 Iref Iref Vss Vss sg13_hv_nmos w=0.8u l=0.5u ng=1 m=1 mm_ok=1
XM13 pd pd Va Va sg13_hv_pmos w=5u l=1u ng=1 m=1 mm_ok=1
XM14 cmfb pd Va Va sg13_hv_pmos w=5u l=1u ng=1 m=1 mm_ok=1
XM11 pd cm otail Vss sg13_hv_nmos w=40u l=1u ng=16 m=1 mm_ok=1
XM12 cmfb Vref otail Vss sg13_hv_nmos w=40u l=1u ng=16 m=1 mm_ok=1
XM10 otail Iref Vss Vss sg13_hv_nmos w=0.8u l=0.5u ng=1 m=1 mm_ok=1
XCc Va cc_g Va Va sg13_hv_pmos w=50u l=5u ng=10 m=1 mm_ok=1
XRc cmfb cc_g Vss rppd w=1u l=6u m=1 b=0 mm_ok=1
XRp Out_p cm Vss rhigh w=1u l=7.35u m=1 b=0 mm_ok=1
XRn Out_n cm Vss rhigh w=1u l=7.35u m=1 b=0 mm_ok=1
XCxp Out_p In_n cap_cmomf w=5.913u l=5.913u mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1 mm_ok=1
XCxn Out_n In_p cap_cmomf w=5.913u l=5.913u mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1 mm_ok=1
XCop Vss Out_p Vss Vss sg13_hv_nmos w=10u l=5u ng=1 m=2 mm_ok=1
XCon Vss Out_n Vss Vss sg13_hv_nmos w=10u l=5u ng=1 m=2 mm_ok=1
.ends


* expanding   symbol:  predriver_comp.sym # of pins=6
** sym_path: macros/lvds_tx/schematic/xschem/predriver_comp.sym
** sch_path: macros/lvds_tx/schematic/xschem/predriver_comp.sch
.subckt predriver_comp Gin Din Iref Out Va Vss
*.iopin Va
*.iopin Vss
*.opin Out
*.ipin Din
*.ipin Gin
*.ipin Iref
XMld net1 net1 Va Va sg13_hv_pmos w=12u l=0.4u ng=4 m=1 mm_ok=1
XMlo Out net1 Va Va sg13_hv_pmos w=12u l=0.4u ng=4 m=1 mm_ok=1
XMid net1 Din net2 Vss sg13_hv_nmos w=24u l=0.45u ng=6 m=1 mm_ok=1
XMio Out Gin net2 Vss sg13_hv_nmos w=24u l=0.45u ng=6 m=1 mm_ok=1
XMt net2 Iref Vss Vss sg13_hv_nmos w=17.52u l=0.45u ng=6 m=2 mm_ok=1
.ends


* expanding   symbol:  predriver_stage.sym # of pins=6
** sym_path: macros/lvds_tx/schematic/xschem/predriver_stage.sym
** sch_path: macros/lvds_tx/schematic/xschem/predriver_stage.sch
.subckt predriver_stage In_p In_n Out_p Out_n Va Vss
*.ipin In_p
*.opin Out_p
*.ipin In_n
*.opin Out_n
*.iopin Va
*.iopin Vss
XMpp0 net1 In_p Va Va sg13_hv_pmos w=2.64u l=0.4u ng=1 m=1 mm_ok=1
XMnp0 net1 In_p Vss Vss sg13_hv_nmos w=1.6u l=0.45u ng=1 m=1 mm_ok=1
XMpp1 net2 net1 Va Va sg13_hv_pmos w=12.52u l=0.4u ng=4 m=1 mm_ok=1
XMnp1 net2 net1 Vss Vss sg13_hv_nmos w=5u l=0.45u ng=4 m=1 mm_ok=1
XMpp2 Out_p net2 Va Va sg13_hv_pmos w=40u l=0.4u ng=10 m=1 mm_ok=1
XMnp2 Out_p net2 Vss Vss sg13_hv_nmos w=16u l=0.45u ng=10 m=1 mm_ok=1
XMpn0 net3 In_n Va Va sg13_hv_pmos w=2.64u l=0.4u ng=1 m=1 mm_ok=1
XMnn0 net3 In_n Vss Vss sg13_hv_nmos w=1.6u l=0.45u ng=1 m=1 mm_ok=1
XMpn1 net4 net3 Va Va sg13_hv_pmos w=12.52u l=0.4u ng=4 m=1 mm_ok=1
XMnn1 net4 net3 Vss Vss sg13_hv_nmos w=5u l=0.45u ng=4 m=1 mm_ok=1
XMpn2 Out_n net4 Va Va sg13_hv_pmos w=40u l=0.4u ng=10 m=1 mm_ok=1
XMnn2 Out_n net4 Vss Vss sg13_hv_nmos w=16u l=0.45u ng=10 m=1 mm_ok=1
XMpxp net4 net2 Va Va sg13_hv_pmos w=4.38u l=0.4u ng=1 m=1 mm_ok=1
XMnxp net4 net2 Vss Vss sg13_hv_nmos w=1.75u l=0.45u ng=1 m=1 mm_ok=1
XMpxn net2 net4 Va Va sg13_hv_pmos w=4.38u l=0.4u ng=1 m=1 mm_ok=1
XMnxn net2 net4 Vss Vss sg13_hv_nmos w=1.75u l=0.45u ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
