** sch_path: macros/lvds_pattern/cace/templates/pattern_timing.sch
**.subckt pattern_timing
VDD VDD GND CACE{vdd}
.save i(vdd)
VREF ref_clk GND PULSE(0 CACE{vdd} 0 CACE{tedge} CACE{tedge} 'CACE{period}/2-CACE{tedge}' CACE{period})
VEN en GND PWL(0 0 CACE{t_en} 0 'CACE{t_en}+CACE{tedge}' CACE{vdd})
VRST reset GND PWL(0 CACE{vdd} CACE{t_rst} CACE{vdd} 'CACE{t_rst}+CACE{tedge}' 0)
VMODE mode GND CACE{vdd}
x1 ref_clk en reset mode D_p D_n VDD GND lvds_pattern
CD_p D_p GND CACE{cload} m=1
CD_n D_n GND CACE{cload} m=1
**** begin user architecture code


* Corner and temperature are conditions, so one template covers the grid.
.lib cornerMOSlv.lib mos_CACE{corner}
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice
* the antenna diodes of antennanp: the PDK model with tt = 0 (scripts/sim/make_diode_models.py)
.include CACE{root}/../../models/diodes_tt0.lib

* schematic, extracted layout or R-C extracted, whichever CACE was asked for
.include CACE{DUT_path}

.temp CACE{temperature}
.option warn=1




.control

    * A single .save in the netlist makes ngspice drop every node voltage that
    * is not named, and savecurrent on the supply emits one. So list them.
    save v(D_p) v(D_n) i(VDD)

    tran CACE{tstep} CACE{tstop}

    * Is the pair complementary at every instant? dsum is twice the common mode
    * of the two outputs, so a pair that ever sits at the same level shows up
    * here as an excursion, whatever the data is doing.
    let dsum = v(D_p)+v(D_n)
    meas tran dsum_min MIN dsum from=CACE{tmeas} to=CACE{tstop}
    meas tran dsum_max MAX dsum from=CACE{tmeas} to=CACE{tstop}
    let dsum_dev = maximum(abs(dsum_max-CACE{vdd}), abs(CACE{vdd}-dsum_min))

    * Output skew: D_p rising against D_n falling on the same bit. This is what
    * the pre-driver sees, and its budget is about 40 ps.
    * Both counts start at tmeas, not at t=0. During power-up one side can
    * emit a transition the other does not, and from then on the two edge
    * indices refer to different bits - which showed up as a skew of three
    * whole bit periods in some corners and 25 ps in others.
    meas tran tp_r WHEN v(D_p)=CACE{vhalf} RISE=CACE{edge} TD=CACE{tmeas}
    meas tran tn_f WHEN v(D_n)=CACE{vhalf} FALL=CACE{edge} TD=CACE{tmeas}
    let skew = abs(tn_f - tp_r)

    meas tran i_vdd AVG i(VDD) from=CACE{tmeas} to=CACE{tstop}
    let i_core = -i_vdd

    echo $&dsum_dev $&skew $&i_core > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends

* expanding   symbol:  lvds_pattern.sym # of pins=8
** sym_path: macros/lvds_pattern/schematic/xschem/lvds_pattern.sym
** sch_path: macros/lvds_pattern/schematic/xschem/lvds_pattern.sch
.subckt lvds_pattern ref_clk en reset mode D_p D_n VDD VSS
*.ipin ref_clk
*.ipin en
*.ipin reset
*.ipin mode
*.opin D_p
*.opin D_n
*.iopin VDD
*.iopin VSS
xicg gclk ref_clk en VDD VSS sg13cmos5l_lgcp_1
xclkb gclk_b gclk VDD VSS sg13cmos5l_buf_4
xicg2 gclk_free ref_clk VDD VDD VSS sg13cmos5l_lgcp_1
xclkb2 gclk_free_b gclk_free VDD VSS sg13cmos5l_buf_4
xrstb reset_b reset VDD VSS sg13cmos5l_inv_2
xs0 s0 s0_n gclk_b fb reset_b VDD VSS sg13cmos5l_dfrbp_2
xs1 s1 s1_n gclk_b s0 reset_b VDD VSS sg13cmos5l_dfrbp_2
xs2 s2 s2_n gclk_b s1 reset_b VDD VSS sg13cmos5l_dfrbp_2
xs3 s3 s3_n gclk_b s2 reset_b VDD VSS sg13cmos5l_dfrbp_2
xs4 s4 s4_n gclk_b s3 reset_b VDD VSS sg13cmos5l_dfrbp_2
xs5 s5 s5_n gclk_b s4 reset_b VDD VSS sg13cmos5l_dfrbp_2
xs6 s6 s6_n gclk_b s5 reset_b VDD VSS sg13cmos5l_dfrbp_2
xfb fb s6 s5 VDD VSS sg13cmos5l_xnor2_1
xclkn gclk_bn gclk_b VDD VSS sg13cmos5l_inv_2
xmodep dp0 gclk_bn fp mode VDD VSS sg13cmos5l_mux2_2
xmoden dn0 gclk_b fn mode VDD VSS sg13cmos5l_mux2_2
xp1 dp1 dp0 VDD VSS sg13cmos5l_inv_2
xp2 dp2 dp1 VDD VSS sg13cmos5l_inv_8
xbp D_p dp2 VDD VSS sg13cmos5l_inv_16
xn1 dn1 dn0 VDD VSS sg13cmos5l_inv_2
xn2 dn2 dn1 VDD VSS sg13cmos5l_inv_8
xbn D_n dn2 VDD VSS sg13cmos5l_inv_16
xffn fn fn_n gclk_free_b s6_i VDD VDD VSS sg13cmos5l_dfrbp_2
xffp fp fp_n gclk_free_b s6 VDD VDD VSS sg13cmos5l_dfrbp_2
x1 VDD VSS sg13cmos5l_decap_4
x2 VDD VSS sg13cmos5l_decap_4
x3 VDD VSS sg13cmos5l_decap_4
x4 VDD VSS sg13cmos5l_decap_4
x5 VDD VSS sg13cmos5l_decap_4
x6 VDD VSS sg13cmos5l_decap_4
x7 VDD VSS sg13cmos5l_decap_8
x8 VDD VSS sg13cmos5l_decap_8
x9 VDD VSS sg13cmos5l_decap_8
x10 VDD VSS sg13cmos5l_decap_8
x11 VDD VSS sg13cmos5l_decap_8
x12 VDD VSS sg13cmos5l_decap_8
x13 VDD VSS sg13cmos5l_decap_8
x14 VDD VSS sg13cmos5l_decap_8
x15 VDD VSS sg13cmos5l_decap_8
x16 VDD VSS sg13cmos5l_decap_8
x17 VDD VSS sg13cmos5l_decap_8
x18 VDD VSS sg13cmos5l_decap_8
x19 VDD VSS sg13cmos5l_decap_8
x20 VDD VSS sg13cmos5l_decap_8
x21 VDD VSS sg13cmos5l_decap_8
x22 VDD VSS sg13cmos5l_decap_8
x23 VDD VSS sg13cmos5l_decap_8
x24 VDD VSS sg13cmos5l_decap_8
x25 VDD VSS sg13cmos5l_decap_8
x26 VDD VSS sg13cmos5l_decap_8
x27 VDD VSS sg13cmos5l_decap_8
x28 VDD VSS sg13cmos5l_decap_8
x29 VDD VSS sg13cmos5l_decap_8
x30 VDD VSS sg13cmos5l_decap_8
x31 VDD VSS sg13cmos5l_decap_8
x32 VDD VSS sg13cmos5l_decap_8
x33 VDD VSS sg13cmos5l_decap_8
x34 VDD VSS sg13cmos5l_decap_8
x35 VDD VSS sg13cmos5l_decap_8
x36 VDD VSS sg13cmos5l_decap_8
x37 VDD VSS sg13cmos5l_decap_8
x38 VDD VSS sg13cmos5l_decap_8
x39 VDD VSS sg13cmos5l_decap_8
x40 VDD VSS sg13cmos5l_decap_8
x41 VDD VSS sg13cmos5l_decap_8
xinvd s6_i s6 VDD VSS sg13cmos5l_inv_1
xant_en en VDD VSS sg13cmos5l_antennanp
xant_mode mode VDD VSS sg13cmos5l_antennanp
xant_ref ref_clk VDD VSS sg13cmos5l_antennanp
.ends

.GLOBAL GND
.end
