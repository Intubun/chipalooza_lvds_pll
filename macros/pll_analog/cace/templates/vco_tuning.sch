** sch_path: macros/pll_analog/cace/templates/vco_tuning.sch
**.subckt vco_tuning
VDD VDD GND CACE{vdd}
.save i(vdd)
VCT VCTRL GND CACE{vctrl}
x1 VCTRL VCO_OUT VDD GND ring_oscillator
**** begin user architecture code


* Corner and temperature are conditions, so one template covers the grid.
.lib cornerMOSlv.lib mos_CACE{corner}

* schematic, extracted layout or R-C extracted, whichever CACE was asked for
.include CACE{DUT_path}

.temp CACE{temperature}
.option warn=1

* A ring oscillator has a perfectly good unstable DC operating point, and
* ngspice will solve for it and then stay there. These three nodes break the
* symmetry so it starts, the same way the block's own benches do it.
.ic v(x1.VCO_CORE)=0 v(x1.net1)=CACE{vdd} v(x1.net2)=0




.control

    save v(VCO_OUT) i(VDD)

    tran CACE{tstep} CACE{tstop}

    * Count a fixed number of crossings and divide, rather than taking one
    * period. The frequency changes by an order of magnitude across the VCTRL
    * sweep, so a single period is both noisy and, at the fast end, shorter
    * than the timestep resolution deserves.
    meas tran t_a WHEN v(VCO_OUT)=CACE{vhalf} RISE=CACE{edge_a}
    meas tran t_b WHEN v(VCO_OUT)=CACE{vhalf} RISE=CACE{edge_b}
    let f_vco = (CACE{edge_b}-CACE{edge_a})/(t_b-t_a)

    * Amplitude tells you whether it is really oscillating rail to rail or
    * just ringing - a frequency measured on a 100 mV wiggle is not a clock.
    meas tran v_max MAX v(VCO_OUT) from=CACE{tmeas} to=CACE{tstop}
    meas tran v_min MIN v(VCO_OUT) from=CACE{tmeas} to=CACE{tstop}
    let v_swing = v_max - v_min

    meas tran i_vdd AVG i(VDD) from=CACE{tmeas} to=CACE{tstop}
    * In amps. CACE takes the number as SI base units and uses the unit
    * field only to scale the display, so declaring uA in the datasheet
    * is what makes this read as tens of microamps rather than 0.000 A.
    * Scaling here as well multiplies it in twice.
    let i_vco = -i_vdd

    echo $&f_vco $&v_swing $&i_vco > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
